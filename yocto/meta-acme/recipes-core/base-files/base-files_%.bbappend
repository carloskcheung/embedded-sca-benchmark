FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

hostname = "acme-gw"
