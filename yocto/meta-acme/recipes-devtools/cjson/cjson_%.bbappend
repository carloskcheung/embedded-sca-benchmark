FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-cJSON-lower-default-nesting-limit.patch"
